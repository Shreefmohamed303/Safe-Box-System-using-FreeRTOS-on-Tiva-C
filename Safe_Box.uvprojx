# Keil uVision project Safe_Box.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Safe_Box
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Src
    ./UART/: uart.c
    ./: main.c
    ./Keypad/: keypad.c
    ./GPIO_Drivers/: EEPROM.c GPIO.c
    ./LCD/: LCD.c
  group inc
    ./Keypad/: keypad.h
    ./GPIO_Drivers/: Data_Type.h EEPROM.h GPIO.h Readme.txt Tiva_C_Ports.h TivaC_IO.h
    ./LCD/: lcd.h
    ./UART/: uart.h
    ./: tm4c123gh6pm.h
software components: RTOS:Config 10.2.1, RTOS:Core 10.2.1, RTOS:Event Groups 10.2.1, RTOS:Heap 10.2.1, RTOS:Timers 10.2.1, CMSIS:CORE 5.3.0, CMSIS:RTOS2:FreeRTOS 10.2.1, Device:Startup 1.0.1
